# Keil uVision project library.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: library +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\sourse
  group main
    ../sourse/: main.c
  group c
    ../sourse/: adc.c ds18b20.c ds1302.c ds1302config.c hc138.c head.c iic.c key.c led.c menu.c onewire.c SMG.c Timer.c uart.c
  group head
    ../sourse/: adc.h config.h ds18b20.h ds1302.h ds1302config.h hc138.h head.h iic.h key.h led.h menu.h onewire.h SMG.h Timer.h uart.h
